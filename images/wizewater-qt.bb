SUMMARY = "A Qt5 image for wizewater"
HOMEPAGE = "http://wizewater.us"
LICENSE = "MIT"

require meta-rpi/images/qt5-image.bb

export IMAGE_BASENAME = "wizewater-qt"

